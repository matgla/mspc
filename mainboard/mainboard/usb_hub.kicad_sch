File: mainboard/mainboard/usb_hub.kicad_sch (KiCad schematic)
At the start: 18 parts, among them U7 hs8836a

Commit message: bumped up kicad to v10
Parts:
- J3, J4: value ~ -> (none)
